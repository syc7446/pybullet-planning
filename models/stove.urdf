Commit message: modify stove.urdf

File: models/stove.urdf (robot description, URDF)
Before this commit: robot stove, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.15 0.15 0.05; visual box size=0.15 0.15 0.05
